# IAR project blink-efwd.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F2122 MSP430F2122
  General.GStackSize2: 120
  General.GHeapSize2: 40
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: ..\lnk430F2122_BLINK.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: car_control.c car_control.h cstartup.s43 emitters.c emitters.h io430x21x2.h leds.c leds.h main.c main.h msp430x21x2.h recievers.c recievers.h small_car-efwd-01.c small_car-efwd-01.h typedef_MSP430.h utilities.c utilities.h
